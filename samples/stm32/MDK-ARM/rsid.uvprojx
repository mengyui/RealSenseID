# Keil uVision project rsid.uvprojx, settings and files
target rsid (6150000::V6.15::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: rsid +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,STM32_HAL
  c misc: -fexceptions
  c include: ../Core/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include;  ..\..\..\3rdparty\mbedtls-2.25.0\include;  ..\..\..\3rdparty\spdlog_1_8_0\include;  ..\..\..\include;  ..\..\..\src\Logger;  ..\..\..\src\PacketManager
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: hardware_rng.c retarget.c retarget_stdio.c utils.c McuSerial.cc stm_logger.cc main.c gpio.c rng.c rtc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rng.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group RealSenseID
    ../../../src/: DeviceController.cc DeviceControllerImpl.cc FaceAuthenticator.cc FaceAuthenticatorImpl.cc Logging.cc StatusHelper.cc Version.cc
    ../../../src/PacketManager/: Crc16.cc MbedtlsWrapper.cc NonSecureSession.cc PacketSender.cc Randomizer.cc SecureSession.cc SerialPacket.cc Timer.cc
    ../../../src/Matcher/: Matcher.cc
  group RealSenseID/example
    ../../../tools/rsid-cli/: main.cc
    ../../../tools/shared/secure-mode-helper/: secure_mode_helper.cc
  group mbedtls
    ../../../3rdparty/mbedtls-2.25.0/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_driver_wrappers.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
target rsid_secure (6150000::V6.15::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: rsid +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,STM32_HAL,RSID_SECURE,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c misc: -fexceptions
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\..\3rdparty\mbedtls-2.25.0\include;..\..\..\3rdparty\spdlog_1_8_0\include;..\..\..\include;..\..\..\src\Logger;..\..\..\src\PacketManager;..\..\..\tools\shared\secure-mode-helper;..\..\..\wrappers\c\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.4.0
